FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

# Restore the normal Nocturne boot mark. This is the upstream 480x800 BMP used
# by Nocturne's superbird-logo append.
SUPERBIRD_BOOT_LOGO_NAME = "nocturne-bootup.bmp"
