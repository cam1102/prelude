SYSTEMD_AUTO_ENABLE:${PN}-adbd = "enable"
