FILESEXTRAPATHS:prepend := "${THISDIR}/files:"

DESCRIPTION = "Renders device metadata and keeps SSH host keys persistent across the read-only root filesystem."
