# Archives ramoops crash dumps to /var/lib/systemd/pstore on the next boot.
PACKAGECONFIG:append = " pstore"
